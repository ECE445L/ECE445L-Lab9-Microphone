# Keil uVision project Lab9R.uvprojx, settings and files
target Lab9R (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab9R
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab9R.c Receiver.c
    ../inc/: LaunchPad.c PLL.c Bump.c SSD1306.c CortexM.c I2C1.c ADCSWTrigger.c Motor.c InputCapture.c Timer2A.c IRDistance.c UART0int.c MotorControl.c Tachometer.c Joystick.c dsp.c
software components: CMSIS:CORE 5.6.0
